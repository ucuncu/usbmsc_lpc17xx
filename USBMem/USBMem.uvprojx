# Keil uVision project USBMem.uvprojx, settings and files
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1766 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USBMem +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __IRAM
  c include: .;..\Common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c memory.c
  group Startup
    ../common/src/: startup_LPC17xx.s
  group Disk Image
    ./: DiskImg.c
  group System
    ../common/src/: system_LPC17xx.c
  group Documentation
    ./: Abstract.txt
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USBMem +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;..\Common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
software components: CMSIS:CORE 5.3.0
